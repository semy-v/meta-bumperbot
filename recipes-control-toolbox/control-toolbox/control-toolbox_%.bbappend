ROS_BUILD_DEPENDS:append = " \
    generate-parameter-library-py \
"

DEPENDS:append = " generate-parameter-library-py-native"