FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI:remove = "file://use-tinyxml-by-name.patch"