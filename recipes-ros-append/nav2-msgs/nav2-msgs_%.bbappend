SRCREV = "70217f3a43f625ed64e7abbaa97a2e4c33d64617"

ROS_BUILD_DEPENDS:append = " rosidl-core-generators rosidl-core-generators-native"