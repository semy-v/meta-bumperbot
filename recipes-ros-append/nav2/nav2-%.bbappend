TARGET_CPPFLAGS:append = " -Wno-error=shadow -Wno-error=non-virtual-dtor"